# Keil uVision project lesson.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: ..\qpc\src\qf;..\qpc\src\qxk;..\qpc\ports\arm-cm\qxk\armclang;..\qpc\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./bsp/: bsp.h gpio.c os.c rcc.c systick.c
    ./drivers/: blinky.c blinky.h
    ./: main.c
  group QPC
    ../qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../qpc/src/qxk/: qxk.c qxk_mutex.c qxk_sema.c qxk_xthr.c
    ../qpc/ports/arm-cm/qxk/armclang/: qxk_port.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
